# Keil uVision project tacho.uvproj, settings and files
target Target 1 (MCS-51)
  device: C515C-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(10000000) XRAM (0xF800-0xFFFF) MOD517DP
  output: tacho
  group Source Group 1
    ./: STARTUP.A51 main.c timer.c tacho.c
